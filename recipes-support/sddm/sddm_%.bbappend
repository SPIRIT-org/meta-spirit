# cmake_minimum_required
EXTRA_OECMAKE += " -DCMAKE_POLICY_VERSION_MINIMUM=3.5 "
