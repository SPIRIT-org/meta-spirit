# Fix for "Nothing PROVIDES 'qtwayland-native' (but .../meta-kde/...) DEPENDS on or otherwise requires it)."
BBCLASSEXTEND += "native"
