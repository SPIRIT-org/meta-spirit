DEPENDS += "qtbase-native"
